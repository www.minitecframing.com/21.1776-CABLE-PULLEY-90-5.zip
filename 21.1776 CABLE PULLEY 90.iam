# Autodesk Inventor assembly: 21.1776 CABLE PULLEY 90
## iProperties
Created: 2007-05
Part Number: 21.1776 CABLE PULLEY 90
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
